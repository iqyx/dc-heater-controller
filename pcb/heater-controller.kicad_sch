File: pcb/heater-controller.kicad_sch (KiCad schematic)
At the start: 4 parts

Commit message: Update sch & pcb
Connections:
- removed net Earth: H1.1, H2.1, H3.1, H4.1
- no-connect marks 0 -> 4
